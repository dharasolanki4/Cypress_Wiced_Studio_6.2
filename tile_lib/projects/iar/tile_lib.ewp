# IAR project tile_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\include; ..\..\src; ..\..\src\drivers; ..\..\src\crypto; ..\..\src\toa; ..\..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group config
    ../../config/: tile_config.h
  group tile_crypto
    ../../src/crypto/: hmac_sha256_ogay.c hmac_sha256_ogay.h sha256_ogay.c sha256_ogay.h uECC.c uECC.h
  group tile_drivers
    ../../src/drivers/: tile_button.c tile_gap.c tile_gatt.c tile_random.c tile_timer.c
  group tile_lib
    ../../src/: crc.c crc.h tileHash.c tileHash.h
  group toa
    ../../src/toa/: queue.c queue.h song.c song.h tcu.c tcu.h tdg.c tdg.h tdi.c tdi.h tdt.c tdt.h test.c test.h tileTime.c tileTime.h tka.c tka.h tmd.c tmd.h tmf.c tmf.h toa.c toa.h tofu.c tofu.h tpc.c tpc.h trm.c trm.h
