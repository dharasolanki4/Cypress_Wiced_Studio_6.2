# Keil uVision project tile_lib.uvprojx, settings and files
target tile_lib (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ..\tile_lib (library)
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\include;..\..\src;..\..\src\drivers;..\..\src\toa;..\..\src\crypto
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group src
    ../../src/: crc.c tileHash.c
  group src/drivers
    ../../src/drivers/: tile_button.c tile_gap.c tile_random.c tile_timer.c
  group src/toa
    ../../src/toa/: queue.c song.c tcu.c tdg.c tdi.c tdt.c test.c tileTime.c tka.c tmd.c tmf.c toa.c tofu.c tpc.c trm.c
  group src/crypto
    ../../src/crypto/: hmac_sha256_ogay.c sha256_ogay.c uECC.c
  group include
    ../../include/: tile_lib.h
  group include/drivers
    ../../include/drivers/: tile_button_driver.h tile_gap_driver.h tile_random_driver.h tile_timer_driver.h
  group include/modules
    ../../include/modules/: tile_adv_int_module.h tile_song_module.h tile_tcu_module.h tile_tdg_module.h tile_tdi_module.h tile_tdt_module.h tile_test_module.h tile_time_module.h tile_tmd_module.h tile_tmf_module.h tile_toa_module.h tile_tofu_module.h tile_tpc_module.h tile_trm_module.h
  group include/crypto
    ../../include/crypto/: hmac_sha256.h sha256.h
