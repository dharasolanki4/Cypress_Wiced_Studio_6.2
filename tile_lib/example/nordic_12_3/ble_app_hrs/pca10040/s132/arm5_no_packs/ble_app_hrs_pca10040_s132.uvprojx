# Keil uVision project ble_app_hrs_pca10040_s132.uvprojx, settings and files
target nrf52832_xxaa (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 NRF_SD_BLE_API_VERSION=3 S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 CONFIG_GPIO_AS_PINRESET NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52832 NRF52
  c include: ..\..\..\config\ble_app_hrs_pca10040_s132;..\..\..\config;../../../../../../../../SDKS/nordic_12_3/components;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_advertising;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_dtm;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_racp;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_ancs_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_ans_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_bas;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_bas_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_cscs;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_cts_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_dfu;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_dis;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_gls;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_hids;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_hrs;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_hrs_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_hts;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_ias;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_ias_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_lbs;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_lbs_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_lls;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_nus;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_nus_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_rscs;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_rscs_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_tps;../../../../../../../../SDKS/nordic_12_3/components\ble\common;../../../../../../../../SDKS/nordic_12_3/components\ble\nrf_ble_gatt;../../../../../../../../SDKS/nordic_12_3/components\ble\nrf_ble_qwr;../../../../../../../../SDKS/nordic_12_3/components\ble\peer_manager;../../../../../../../../SDKS/nordic_12_3/components\boards;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\adc;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\clock;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\common;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\comp;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\delay;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\gpiote;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\hal;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\i2s;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\lpcomp;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\pdm;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\power;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\ppi;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\pwm;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\qdec;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\rng;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\rtc;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\saadc;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\spi_master;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\spi_slave;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\swi;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\timer;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\twi_master;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\twis_slave;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\uart;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\usbd;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\wdt;../../../../../../../../SDKS/nordic_12_3/components\libraries\bsp;../../../../../../../../SDKS/nordic_12_3/components\libraries\button;../../../../../../../../SDKS/nordic_12_3/components\libraries\crc16;../../../../../../../../SDKS/nordic_12_3/components\libraries\crc32;../../../../../../../../SDKS/nordic_12_3/components\libraries\csense;../../../../../../../../SDKS/nordic_12_3/components\libraries\csense_drv;../../../../../../../../SDKS/nordic_12_3/components\libraries\experimental_section_vars;../../../../../../../../SDKS/nordic_12_3/components\libraries\fds;../../../../../../../../SDKS/nordic_12_3/components\libraries\fstorage;../../../../../../../../SDKS/nordic_12_3/components\libraries\gpiote;../../../../../../../../SDKS/nordic_12_3/components\libraries\hardfault;../../../../../../../../SDKS/nordic_12_3/components\libraries\hci;../../../../../../../../SDKS/nordic_12_3/components\libraries\led_softblink;../../../../../../../../SDKS/nordic_12_3/components\libraries\log;../../../../../../../../SDKS/nordic_12_3/components\libraries\log\src;../../../../../../../../SDKS/nordic_12_3/components\libraries\low_power_pwm;../../../../../../../../SDKS/nordic_12_3/components\libraries\mem_manager;../../../../../../../../SDKS/nordic_12_3/components\libraries\pwm;../../../../../../../../SDKS/nordic_12_3/components\libraries\queue;../../../../../../../../SDKS/nordic_12_3/components\libraries\scheduler;../../../../../../../../SDKS/nordic_12_3/components\libraries\sensorsim;../../../../../../../../SDKS/nordic_12_3/components\libraries\slip;../../../../../../../../SDKS/nordic_12_3/components\libraries\timer;../../../../../../../../SDKS/nordic_12_3/components\libraries\twi;../../../../../../../../SDKS/nordic_12_3/components\libraries\uart;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\audio;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\cdc;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\cdc\acm;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\hid;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\hid\generic;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\hid\kbd;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\hid\mouse;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\msc;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\config;../../../../../../../../SDKS/nordic_12_3/components\libraries\util;../../../../../../../../SDKS/nordic_12_3/components\softdevice\common\softdevice_handler;../../../../../../../../SDKS/nordic_12_3/components\softdevice\s132\headers;../../../../../../../../SDKS/nordic_12_3/components\softdevice\s132\headers\nrf52;../../../../../../../../SDKS/nordic_12_3/components\toolchain;../../../../../../../../SDKS/nordic_12_3/external\segger_rtt;..\config;..\..\..\..\..\..\include;..\..\..\..\..\nordic12_common
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__HEAP_SIZE=0,-DNRF_SD_BLE_API_VERSION=3,-DS132,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DSWI_DISABLE0,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52
  asm include: ..\..\..\config\ble_app_hrs_pca10040_s132;..\..\..\config;../../../../../../../../SDKS/nordic_12_3/components;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_advertising;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_dtm;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_racp;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_ancs_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_ans_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_bas;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_bas_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_cscs;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_cts_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_dfu;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_dis;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_gls;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_hids;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_hrs;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_hrs_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_hts;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_ias;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_ias_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_lbs;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_lbs_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_lls;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_nus;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_nus_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_rscs;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_rscs_c;../../../../../../../../SDKS/nordic_12_3/components\ble\ble_services\ble_tps;../../../../../../../../SDKS/nordic_12_3/components\ble\common;../../../../../../../../SDKS/nordic_12_3/components\ble\nrf_ble_gatt;../../../../../../../../SDKS/nordic_12_3/components\ble\nrf_ble_qwr;../../../../../../../../SDKS/nordic_12_3/components\ble\peer_manager;../../../../../../../../SDKS/nordic_12_3/components\boards;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\adc;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\clock;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\common;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\comp;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\delay;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\gpiote;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\hal;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\i2s;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\lpcomp;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\pdm;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\power;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\ppi;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\pwm;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\qdec;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\rng;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\rtc;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\saadc;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\spi_master;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\spi_slave;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\swi;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\timer;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\twi_master;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\twis_slave;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\uart;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\usbd;../../../../../../../../SDKS/nordic_12_3/components\drivers_nrf\wdt;../../../../../../../../SDKS/nordic_12_3/components\libraries\bsp;../../../../../../../../SDKS/nordic_12_3/components\libraries\button;../../../../../../../../SDKS/nordic_12_3/components\libraries\crc16;../../../../../../../../SDKS/nordic_12_3/components\libraries\crc32;../../../../../../../../SDKS/nordic_12_3/components\libraries\csense;../../../../../../../../SDKS/nordic_12_3/components\libraries\csense_drv;../../../../../../../../SDKS/nordic_12_3/components\libraries\experimental_section_vars;../../../../../../../../SDKS/nordic_12_3/components\libraries\fds;../../../../../../../../SDKS/nordic_12_3/components\libraries\fstorage;../../../../../../../../SDKS/nordic_12_3/components\libraries\gpiote;../../../../../../../../SDKS/nordic_12_3/components\libraries\hardfault;../../../../../../../../SDKS/nordic_12_3/components\libraries\hci;../../../../../../../../SDKS/nordic_12_3/components\libraries\led_softblink;../../../../../../../../SDKS/nordic_12_3/components\libraries\log;../../../../../../../../SDKS/nordic_12_3/components\libraries\log\src;../../../../../../../../SDKS/nordic_12_3/components\libraries\low_power_pwm;../../../../../../../../SDKS/nordic_12_3/components\libraries\mem_manager;../../../../../../../../SDKS/nordic_12_3/components\libraries\pwm;../../../../../../../../SDKS/nordic_12_3/components\libraries\queue;../../../../../../../../SDKS/nordic_12_3/components\libraries\scheduler;../../../../../../../../SDKS/nordic_12_3/components\libraries\sensorsim;../../../../../../../../SDKS/nordic_12_3/components\libraries\slip;../../../../../../../../SDKS/nordic_12_3/components\libraries\timer;../../../../../../../../SDKS/nordic_12_3/components\libraries\twi;../../../../../../../../SDKS/nordic_12_3/components\libraries\uart;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\audio;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\cdc;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\cdc\acm;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\hid;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\hid\generic;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\hid\kbd;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\hid\mouse;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\class\msc;../../../../../../../../SDKS/nordic_12_3/components\libraries\usbd\config;../../../../../../../../SDKS/nordic_12_3/components\libraries\util;../../../../../../../../SDKS/nordic_12_3/components\softdevice\common\softdevice_handler;../../../../../../../../SDKS/nordic_12_3/components\softdevice\s132\headers;../../../../../../../../SDKS/nordic_12_3/components\softdevice\s132\headers\nrf52;../../../../../../../../SDKS/nordic_12_3/components\toolchain;../../../../../../../../SDKS/nordic_12_3/external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002c38 size 0xd3c8
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../../SDKS/nordic_12_3/components/boards/: boards.c
  group Board Support
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group nRF_BLE
    ../../../../../../../../SDKS/nordic_12_3/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../../../SDKS/nordic_12_3/components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../../SDKS/nordic_12_3/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../../../../../SDKS/nordic_12_3/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../../../../../../../SDKS/nordic_12_3/components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../../../SDKS/nordic_12_3/components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../../../SDKS/nordic_12_3/components/ble/ble_services/ble_hrs/: ble_hrs.c
  group nRF_Drivers
    ../../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/timer/: nrf_drv_timer.c
  group nRF_Libraries
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/button/: app_button.c
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/crc16/: crc16.c
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/fds/: fds.c
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/fstorage/: fstorage.c
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/sensorsim/: sensorsim.c
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/queue/: nrf_queue.c
  group nRF_Log
    ../../../../../../../../SDKS/nordic_12_3/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../../../../SDKS/nordic_12_3/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../../../SDKS/nordic_12_3/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group Tile_Support
    ../../../../../nordic12_common/: tile_gatt_db.c tile_player.c tile_service.c tile_storage.c
  group Tile_Lib
    ../../../../../../projects/keil/: tile_lib.lib
target flash_s132_nrf52_3.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_hrs_pca10040_s132;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002c38 size 0xd3c8
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
