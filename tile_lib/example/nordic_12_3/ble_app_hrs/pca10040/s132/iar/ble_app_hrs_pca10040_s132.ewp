# IAR project ble_app_hrs_pca10040_s132.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nRF52832-xxAA NordicSemi nRF52832-xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; __HEAP_SIZE=0; NRF_SD_BLE_API_VERSION=3; S132; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; CONFIG_GPIO_AS_PINRESET; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_64; SWI_DISABLE0; SOFTDEVICE_PRESENT; NRF52832; NRF52
  ICCARM.CCIncludePath2: ..\..\..\config\ble_app_hrs_pca10040_s132; ..\..\..\config; $SDK_DIR$\components; $SDK_DIR$\components\ble\ble_advertising; $SDK_DIR$\components\ble\ble_dtm; $SDK_DIR$\components\ble\ble_racp; $SDK_DIR$\components\ble\ble_services\ble_ancs_c; $SDK_DIR$\components\ble\ble_services\ble_ans_c; $SDK_DIR$\components\ble\ble_services\ble_bas; $SDK_DIR$\components\ble\ble_services\ble_bas_c; $SDK_DIR$\components\ble\ble_services\ble_cscs; $SDK_DIR$\components\ble\ble_services\ble_cts_c; $SDK_DIR$\components\ble\ble_services\ble_dfu; $SDK_DIR$\components\ble\ble_services\ble_dis; $SDK_DIR$\components\ble\ble_services\ble_gls; $SDK_DIR$\components\ble\ble_services\ble_hids; $SDK_DIR$\components\ble\ble_services\ble_hrs; $SDK_DIR$\components\ble\ble_services\ble_hrs_c; $SDK_DIR$\components\ble\ble_services\ble_hts; $SDK_DIR$\components\ble\ble_services\ble_ias; $SDK_DIR$\components\ble\ble_services\ble_ias_c; $SDK_DIR$\components\ble\ble_services\ble_lbs; $SDK_DIR$\components\ble\ble_services\ble_lbs_c; $SDK_DIR$\components\ble\ble_services\ble_lls; $SDK_DIR$\components\ble\ble_services\ble_nus; $SDK_DIR$\components\ble\ble_services\ble_nus_c; $SDK_DIR$\components\ble\ble_services\ble_rscs; $SDK_DIR$\components\ble\ble_services\ble_rscs_c; $SDK_DIR$\components\ble\ble_services\ble_tps; $SDK_DIR$\components\ble\common; $SDK_DIR$\components\ble\nrf_ble_gatt; $SDK_DIR$\components\ble\nrf_ble_qwr; $SDK_DIR$\components\ble\peer_manager; $SDK_DIR$\components\boards; $SDK_DIR$\components\device; $SDK_DIR$\components\drivers_nrf\adc; $SDK_DIR$\components\drivers_nrf\clock; $SDK_DIR$\components\drivers_nrf\common; $SDK_DIR$\components\drivers_nrf\comp; $SDK_DIR$\components\drivers_nrf\delay; $SDK_DIR$\components\drivers_nrf\gpiote; $SDK_DIR$\components\drivers_nrf\hal; $SDK_DIR$\components\drivers_nrf\i2s; $SDK_DIR$\components\drivers_nrf\lpcomp; $SDK_DIR$\components\drivers_nrf\pdm; $SDK_DIR$\components\drivers_nrf\power; $SDK_DIR$\components\drivers_nrf\ppi; $SDK_DIR$\components\drivers_nrf\pwm; $SDK_DIR$\components\drivers_nrf\qdec; $SDK_DIR$\components\drivers_nrf\rng; $SDK_DIR$\components\drivers_nrf\rtc; $SDK_DIR$\components\drivers_nrf\saadc; $SDK_DIR$\components\drivers_nrf\spi_master; $SDK_DIR$\components\drivers_nrf\spi_slave; $SDK_DIR$\components\drivers_nrf\swi; $SDK_DIR$\components\drivers_nrf\timer; $SDK_DIR$\components\drivers_nrf\twi_master; $SDK_DIR$\components\drivers_nrf\twis_slave; $SDK_DIR$\components\drivers_nrf\uart; $SDK_DIR$\components\drivers_nrf\usbd; $SDK_DIR$\components\drivers_nrf\wdt; $SDK_DIR$\components\libraries\bsp; $SDK_DIR$\components\libraries\button; $SDK_DIR$\components\libraries\crc16; $SDK_DIR$\components\libraries\crc32; $SDK_DIR$\components\libraries\csense; $SDK_DIR$\components\libraries\csense_drv; $SDK_DIR$\components\libraries\experimental_section_vars; $SDK_DIR$\components\libraries\fds; $SDK_DIR$\components\libraries\fstorage; $SDK_DIR$\components\libraries\gpiote; $SDK_DIR$\components\libraries\hardfault; $SDK_DIR$\components\libraries\hci; $SDK_DIR$\components\libraries\led_softblink; $SDK_DIR$\components\libraries\log; $SDK_DIR$\components\libraries\log\src; $SDK_DIR$\components\libraries\low_power_pwm; $SDK_DIR$\components\libraries\mem_manager; $SDK_DIR$\components\libraries\pwm; $SDK_DIR$\components\libraries\queue; $SDK_DIR$\components\libraries\scheduler; $SDK_DIR$\components\libraries\sensorsim; $SDK_DIR$\components\libraries\slip; $SDK_DIR$\components\libraries\timer; $SDK_DIR$\components\libraries\twi; $SDK_DIR$\components\libraries\uart; $SDK_DIR$\components\libraries\usbd; $SDK_DIR$\components\libraries\usbd\class\audio; $SDK_DIR$\components\libraries\usbd\class\cdc; $SDK_DIR$\components\libraries\usbd\class\cdc\acm; $SDK_DIR$\components\libraries\usbd\class\hid; $SDK_DIR$\components\libraries\usbd\class\hid\generic; $SDK_DIR$\components\libraries\usbd\class\hid\kbd; $SDK_DIR$\components\libraries\usbd\class\hid\mouse; $SDK_DIR$\components\libraries\usbd\class\msc; $SDK_DIR$\components\libraries\usbd\config; $SDK_DIR$\components\libraries\util; $SDK_DIR$\components\softdevice\common\softdevice_handler; $SDK_DIR$\components\softdevice\s132\headers; $SDK_DIR$\components\softdevice\s132\headers\nrf52; $SDK_DIR$\components\toolchain; $SDK_DIR$\components\toolchain\cmsis\include; $SDK_DIR$\external\segger_rtt; ..\config; ..\..\..\..\..\nordic12_common; ..\..\..\..\..\..\tile_lib\include; tile_support
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\..\..\config\ble_app_hrs_pca10040_s132; ..\..\..\config; $SDK_DIR$\components; $SDK_DIR$\components\ble\ble_advertising; $SDK_DIR$\components\ble\ble_dtm; $SDK_DIR$\components\ble\ble_racp; $SDK_DIR$\components\ble\ble_services\ble_ancs_c; $SDK_DIR$\components\ble\ble_services\ble_ans_c; $SDK_DIR$\components\ble\ble_services\ble_bas; $SDK_DIR$\components\ble\ble_services\ble_bas_c; $SDK_DIR$\components\ble\ble_services\ble_cscs; $SDK_DIR$\components\ble\ble_services\ble_cts_c; $SDK_DIR$\components\ble\ble_services\ble_dfu; $SDK_DIR$\components\ble\ble_services\ble_dis; $SDK_DIR$\components\ble\ble_services\ble_gls; $SDK_DIR$\components\ble\ble_services\ble_hids; $SDK_DIR$\components\ble\ble_services\ble_hrs; $SDK_DIR$\components\ble\ble_services\ble_hrs_c; $SDK_DIR$\components\ble\ble_services\ble_hts; $SDK_DIR$\components\ble\ble_services\ble_ias; $SDK_DIR$\components\ble\ble_services\ble_ias_c; $SDK_DIR$\components\ble\ble_services\ble_lbs; $SDK_DIR$\components\ble\ble_services\ble_lbs_c; $SDK_DIR$\components\ble\ble_services\ble_lls; $SDK_DIR$\components\ble\ble_services\ble_nus; $SDK_DIR$\components\ble\ble_services\ble_nus_c; $SDK_DIR$\components\ble\ble_services\ble_rscs; $SDK_DIR$\components\ble\ble_services\ble_rscs_c; $SDK_DIR$\components\ble\ble_services\ble_tps; $SDK_DIR$\components\ble\common; $SDK_DIR$\components\ble\nrf_ble_gatt; $SDK_DIR$\components\ble\nrf_ble_qwr; $SDK_DIR$\components\ble\peer_manager; $SDK_DIR$\components\boards; $SDK_DIR$\components\device; $SDK_DIR$\components\drivers_nrf\adc; $SDK_DIR$\components\drivers_nrf\clock; $SDK_DIR$\components\drivers_nrf\common; $SDK_DIR$\components\drivers_nrf\comp; $SDK_DIR$\components\drivers_nrf\delay; $SDK_DIR$\components\drivers_nrf\gpiote; $SDK_DIR$\components\drivers_nrf\hal; $SDK_DIR$\components\drivers_nrf\i2s; $SDK_DIR$\components\drivers_nrf\lpcomp; $SDK_DIR$\components\drivers_nrf\pdm; $SDK_DIR$\components\drivers_nrf\power; $SDK_DIR$\components\drivers_nrf\ppi; $SDK_DIR$\components\drivers_nrf\pwm; $SDK_DIR$\components\drivers_nrf\qdec; $SDK_DIR$\components\drivers_nrf\rng; $SDK_DIR$\components\drivers_nrf\rtc; $SDK_DIR$\components\drivers_nrf\saadc; $SDK_DIR$\components\drivers_nrf\spi_master; $SDK_DIR$\components\drivers_nrf\spi_slave; $SDK_DIR$\components\drivers_nrf\swi; $SDK_DIR$\components\drivers_nrf\timer; $SDK_DIR$\components\drivers_nrf\twi_master; $SDK_DIR$\components\drivers_nrf\twis_slave; $SDK_DIR$\components\drivers_nrf\uart; $SDK_DIR$\components\drivers_nrf\usbd; $SDK_DIR$\components\drivers_nrf\wdt; $SDK_DIR$\components\libraries\bsp; $SDK_DIR$\components\libraries\button; $SDK_DIR$\components\libraries\crc16; $SDK_DIR$\components\libraries\crc32; $SDK_DIR$\components\libraries\csense; $SDK_DIR$\components\libraries\csense_drv; $SDK_DIR$\components\libraries\experimental_section_vars; $SDK_DIR$\components\libraries\fds; $SDK_DIR$\components\libraries\fstorage; $SDK_DIR$\components\libraries\gpiote; $SDK_DIR$\components\libraries\hardfault; $SDK_DIR$\components\libraries\hci; $SDK_DIR$\components\libraries\led_softblink; $SDK_DIR$\components\libraries\log; $SDK_DIR$\components\libraries\log\src; $SDK_DIR$\components\libraries\low_power_pwm; $SDK_DIR$\components\libraries\mem_manager; $SDK_DIR$\components\libraries\pwm; $SDK_DIR$\components\libraries\queue; $SDK_DIR$\components\libraries\scheduler; $SDK_DIR$\components\libraries\sensorsim; $SDK_DIR$\components\libraries\slip; $SDK_DIR$\components\libraries\timer; $SDK_DIR$\components\libraries\twi; $SDK_DIR$\components\libraries\uart; $SDK_DIR$\components\libraries\usbd; $SDK_DIR$\components\libraries\usbd\class\audio; $SDK_DIR$\components\libraries\usbd\class\cdc; $SDK_DIR$\components\libraries\usbd\class\cdc\acm; $SDK_DIR$\components\libraries\usbd\class\hid; $SDK_DIR$\components\libraries\usbd\class\hid\generic; $SDK_DIR$\components\libraries\usbd\class\hid\kbd; $SDK_DIR$\components\libraries\usbd\class\hid\mouse; $SDK_DIR$\components\libraries\usbd\class\msc; $SDK_DIR$\components\libraries\usbd\config; $SDK_DIR$\components\libraries\util; $SDK_DIR$\components\softdevice\common\softdevice_handler; $SDK_DIR$\components\softdevice\s132\headers; $SDK_DIR$\components\softdevice\s132\headers\nrf52; $SDK_DIR$\components\toolchain; $SDK_DIR$\components\toolchain\cmsis\include; $SDK_DIR$\external\segger_rtt; ..\config
  OBJCOPY.OOCOutputFile: ble_app_hrs_pca10040_s132.hex
  ILINK.IlinkOutputFile: ble_app_hrs_pca10040_s132.out
  ILINK.IlinkIcfFile: ble_app_hrs_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../SDKS/nordic_12_3/components/boards/: boards.c
  group Board Support
    ../../../../../../../SDKS/nordic_12_3/components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group Device
    ../../../../../../../SDKS/nordic_12_3/components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../../SDKS/nordic_12_3/components/toolchain/: system_nrf52.c
  group nRF_BLE
    ../../../../../../../SDKS/nordic_12_3/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../../SDKS/nordic_12_3/components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../SDKS/nordic_12_3/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../../../../../../../SDKS/nordic_12_3/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_BLE_Services
    ../../../../../../../SDKS/nordic_12_3/components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../../SDKS/nordic_12_3/components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../../SDKS/nordic_12_3/components/ble/ble_services/ble_hrs/: ble_hrs.c
  group nRF_Drivers
    ../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../../../SDKS/nordic_12_3/components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../../SDKS/nordic_12_3/components/libraries/button/: app_button.c
    ../../../../../../../SDKS/nordic_12_3/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../../../../../../../SDKS/nordic_12_3/components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../SDKS/nordic_12_3/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../../SDKS/nordic_12_3/components/libraries/crc16/: crc16.c
    ../../../../../../../SDKS/nordic_12_3/components/libraries/fds/: fds.c
    ../../../../../../../SDKS/nordic_12_3/components/libraries/fstorage/: fstorage.c
    ../../../../../../../SDKS/nordic_12_3/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../SDKS/nordic_12_3/components/libraries/queue/: nrf_queue.c
    ../../../../../../../SDKS/nordic_12_3/components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    ../../../../../../../SDKS/nordic_12_3/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../../../SDKS/nordic_12_3/external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../../SDKS/nordic_12_3/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group Tile_Lib
    ../../../../../../tile_lib/projects/iar/Debug/Exe/: tile_lib.a
  group Tile_Service
    ../../../../../nordic12_common/: tile_gatt_db.c tile_player.c tile_service.c tile_storage.c
